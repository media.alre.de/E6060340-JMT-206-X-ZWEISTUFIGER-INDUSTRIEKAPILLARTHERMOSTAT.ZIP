Properties of the parts of a building model (IFC4)

# File
Description: Kapillar-Thermostat, Wandmontage, 20…80 °C, 2-stufig, Schaltdifferenz zwischen den Stufen einstellbar 1…7 K, Kapillarlänge 1,5 m, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: E6060340, Kapillar-Thermostat, Wandmontage, 20…80 °C, 2-stufig, Schaltdifferenz zwischen den Stufen einstellbar 1…7 K, Kapillarlänge 1,5 m
In: Raum
Description: Mehrstufige Regelung der Temperatur flüssiger oder gasförmiger Medien, z. B. Ansteuerung von zweistufigen Brennern oder Heizregistern. Bei Temperaturregelung nicht aggressiver Gase im Kanal ist die Schutzwendel SW-200–12, bei Temperaturregelung in nicht aggressiven Fluiden ist die Tauchhülse TH, in aggressiven Fluiden die Tauchhülse NTH zu verwenden. Tauchhülsen oder Schutzwendel gehören nicht zum Lieferumfang.; Classification: EC002616 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: E6060340; ModelLabel: JMT-206 X; GlobalTradeItemNumber: 4050528029805; ProductURL: https://alre.de/produkt_E6060340
Pset_Specification - NominalLength: 0.136 m; NominalWidth: 0.088 m; NominalDepth: 0.085 m; NetWeight: 0.535
Pset_ALRE_ETIM_Properties - Max. Betriebstemperatur: 55; Ausführung des Sensors: Kapillarrohr; Ausführung des elektrischen Anschlusses: Schraubanschluss; Explosionsgeschützt: no; Schutzart (IP): IP65; Elektronische Ausführung: no; Geeignet als 2 Punktregler: yes; Mediumtemperatur: -15; Schaltdifferenz der Temperatur: 1; Anzahl der Kontakte als Wechsler: 1; ETIM-Klasse: EC002616; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-E6060340.pdf
